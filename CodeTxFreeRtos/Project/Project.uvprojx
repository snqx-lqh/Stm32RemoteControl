# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Project;..\CMSIS\Core;..\CMSIS\STM32F10x;..\Lib\inc;..\USER\BSP;..\USER\APP;..\USER\TASK;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3;..\LetterShell;..\AnoPTv8;..\USER\GAME;..\USER\DEVICE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
    ../CMSIS/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
  group CMSIS
    ../CMSIS/Core/: core_cm3.c
    ../CMSIS/Startup/: startup_stm32f10x_hd.s
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group Bsp
    ../USER/BSP/: bsp_sys.c bsp_delay.c bsp_usart.c bsp_led.c bsp_adc.c bsp_key.c bsp_soft_i2c.c bsp_soft_spi.c bsp_spi.c
  group App
    ../USER/APP/: GUI.c keyscan.c ahrs.c utils.c filter.c
  group Task
    ../USER/TASK/: start_task.c user_task.c nrf_task.c gui_task.c shell_task.c rc_data_task.c ano_task.c game_task.c
  group Device
    ../USER/DEVICE/: mpu6050_driver.c mpu6050_middle.c ssd1306_oled_driver.c ssd1306_oled_middle.c nrf24L01_driver.c nrf24L01_middle.c
  group Game
    ../USER/GAME/: ball_game.c snake_game.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group LetterShell
    ../LetterShell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c shell_cfg.h
  group AnoPTv8
    ../AnoPTv8/: AnoPTv8Cmd.c AnoPTv8FrameFactory.c AnoPTv8Par.c AnoPTv8Run.c HWInterface.c AnoPTv8.h
